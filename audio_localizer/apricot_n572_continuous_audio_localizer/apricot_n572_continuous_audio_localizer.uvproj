# Keil uVision project apricot_n572_continuous_audio_localizer.uvproj, settings and files
target F072_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: N572F072 Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x11FFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: apricot_n572_continuous_audio_localizer
  AfterMake: fromelf --i32combined --output F072\Debug\apricot_n572_continuous_audio_localizer.hex F072\Debug\apricot_n572_continuous_audio_localizer.axf
  AfterMake: ../Nuvoton/WindowsPlatform/Tool/Utility/hex2bin F072\Debug\apricot_n572_continuous_audio_localizer.hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __N572F072__
  c include: .;../Nuvoton/HW/Include;../Nuvoton/Include;../RTX/INC;nRF8001;nRF8001/hal
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\apricot_n572_continuous_audio_localizer_F072_Keil.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../Nuvoton/Lib" Driver_F072_keil.lib
  group Header Files
    ./: SysClkConfig.h Adc.h Spi.h LED.h
  group Source Files
    ../Nuvoton/HW/Include/: SFR.c
    ./: Main.c Adc.c Spi.c LED.c
  group CMSIS
    ../Nuvoton/CMSIS/CM0/startup/arm/: startup_N572_Keil.s
    ../Nuvoton/CMSIS/CM0/: core_cm0.c
  group Documentation
    ./: Abstract.txt
target F072_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: N572F072 Nuvoton
  cpu: as above
  output: RevB_Head_Keil
  AfterMake: fromelf --i32combined --output F072\Release\RevB_Head_Keil.hex F072\Release\RevB_Head_Keil.axf
  AfterMake: ../../../../WindowsPlatform/Tool/Utility/hex2bin F072\Release\RevB_Head_Keil.hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __EVB_V1_0__,__N572F072__
  c include: .;../../../../HW/Include;../../../Include;../RTX/INC;nRF8001;nRF8001/hal
  asm define: __N572F072__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\RevB_Head_F072_Keil.ld
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler --remove --userlibpath="../../../lib" Driver_F072_keil.lib
